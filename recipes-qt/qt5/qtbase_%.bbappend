PACKAGECONFIG_append = " sql-sqlite accessibility gles2 openssl"
