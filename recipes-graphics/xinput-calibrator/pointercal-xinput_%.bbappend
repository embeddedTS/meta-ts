# Append path for ts layer to include bsp pointercal.xinput
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
